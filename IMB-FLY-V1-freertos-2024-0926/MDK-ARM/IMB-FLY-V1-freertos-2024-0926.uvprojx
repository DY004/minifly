# Keil uVision project IMB-FLY-V1-freertos-2024-0926.uvprojx, settings and files
target IMB-FLY-V1-freertos-2024-0926 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: IMB-FLY-V1-freertos-2024-0926 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/STM32F1xx_HAL_Driver/Inc;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../HARDWARE/battery_adc;../HARDWARE/PWR_ON;../HARDWARE/PWR_ON_OFF;../SYSTEM/delay;../SYSTEM/sys;../HARDWARE/WS2812B_led;../HARDWARE;../HARDWARE/iic;../HARDWARE/si24r1;../CONTROL;../COMMUNICATE;../HARDWARE/flash;../IMU;../HARDWARE/mpu6050;../HARDWARE/motor;../HARDWARE/fbm320
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group HARDWARE
    ../HARDWARE/PWR_ON/: PWR_ON.C
    ../HARDWARE/PWR_ON_OFF/: PWR_ON_OFF.C
    ../HARDWARE/battery_adc/: battery_adc.C
    ../HARDWARE/WS2812B_led/: WS2812B_led.c
    ../HARDWARE/iic/: iic.c
    ../HARDWARE/si24r1/: si24r1.c
    ../HARDWARE/mpu6050/: mpu6050.c
    ../HARDWARE/flash/: stmflash.c
    ../HARDWARE/motor/: motor.c
    ../HARDWARE/fbm320/: fbm320.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group CONTROL
    ../CONTROL/: paramsave.c pid.c control.c altitude.c
  group COMMUNICATE
    ../COMMUNICATE/: remotedata.c ANO_DT.c
  group IMU
    ../IMU/: imu.c filter.c
software components: CMSIS:CORE 4.3.0
